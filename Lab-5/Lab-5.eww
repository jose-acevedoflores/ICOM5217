<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\part1\part1.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\part2\part2.ewp</path>
  </project>
  <batchBuild/>
</workspace>


